# Copyright (c) 2022 Wind River Systems, Inc.

ROS_EXEC_DEPENDS:remove = "rviz2"
RDEPENDS:${PN} += "bash"
