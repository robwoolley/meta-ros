# Copyright (c) 2022 Wind River Systems, Inc.

ROS_EXEC_DEPENDS:remove = "rviz2"
ROS_EXEC_DEPENDS:remove = "joint-state-publisher-gui"
ROS_EXEC_DEPENDS += "joint-state-publisher"
