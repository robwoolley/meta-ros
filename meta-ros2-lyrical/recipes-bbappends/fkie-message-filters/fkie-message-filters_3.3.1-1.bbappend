# Copyright (c) 2026 Wind River Systems, Inc.

# QA Issue: non -dev/-dbg/nativesdk- package fkie-message-filters contains
# symlink .so 'libfkie_message_filters.so' [dev-so]
inherit ros_insane_dev_so
