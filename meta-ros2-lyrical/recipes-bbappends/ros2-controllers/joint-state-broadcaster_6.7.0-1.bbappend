# Copyright (c) 2021 LG Electronics, Inc.

FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

ROS_BUILDTOOL_DEPENDS += "\
    generate-parameter-library-py-native \
"
